# Keil uVision project mpu.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: mpu +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\BSP\LED;..\HARDWARE\BSP\KEY;..\HARDWARE\BSP\SERIAL;..\HARDWARE\BSP\CAP;..\HARDWARE\BSP\ADC;..\HARDWARE\BSP\CCD;..\HARDWARE\BSP\MOTOR;..\HARDWARE\BSP\TIMER;..\HARDWARE\BSP\OPENMV;..\HARDWARE\MPU\MPU6050\eMPL;..\HARDWARE\MPU\MPU6050;..\SYSTEM\exit;..\SYSTEM\adc;..\SYSTEM\GeneralTim
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: stm32f10x_it.c system_stm32f10x.c main.c
  group HARDWARE
    ../HARDWARE/MPU/MPU6050/: mpu6050.c mpuiic.c
    ../HARDWARE/BSP/I2C/: bsp_iic.c bsp_iic.h
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../HARDWARE/MPU/MPU6050/: oled.c
    ../SYSTEM/exit/: exti.c exti.h
    ../SYSTEM/adc/: adc.c
    ../SYSTEM/GeneralTim/: bsp_GeneralTim.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group MPU
    ../HARDWARE/MPU/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
